## Config.in
```kconfig
config BR2_PACKAGE_PODMAN
    bool "podman"
    depends on BR2_TOOLCHAIN_HAS_THREADS
```
